FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://usb-network.scc "
